# Repository tokai-student-rocket-project/Gen6-GSE-Elec (continued)

## KiCad design KiCad/SatelliteController2.0/SatelliteController2.0.kicad_pcb (continued)

Parts:
C37: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D27, D28, D29, D30, D31, D32, D33, D34, D35: GS1010FL; D_SOD-123F
J14: RELAY_POWER; TerminalBlock_WAGO_2601-3102_1x02_P3.50mm_Vertical; Digikey_PN 2946-2601-3102-ND
J15: IGNITOR; TerminalBlock_WAGO_2601-3102_1x02_P3.50mm_Vertical; Digikey_PN 2946-2601-3102-ND
J16: CONN_SORENOID_VALVE; DF51A-8DP-2DS; Mouser_PN 798-DF51A-8DP-2DSA
Q4, Q5, Q6, Q7, Q8, Q9, Q10, Q11, Q12, Q13: AO3400A; SOT-23; Digikey_PN 785-1000-1-ND
R58, R60, R64, R65, R68, R74, R76, R82, R84, R86: 120R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Digikey_PN 2019-RK73H1JTTD1200FCT-ND
R59, R61, R66, R67, R69, R75, R77, R83, R85, R87: 10kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Digikey_PN 2019-RK73H1JTTD1002FCT-ND
R62, R70, R72, R78, R80, R88, R90, R92: 56kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Digikey_PN 2019-RK73H1JTTD5602FCT-ND
R63, R71, R73, R79, R81, R89, R91, R93: 33kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Digikey_PN 2019-RK73H1JTTD3302FCT-ND
U12: MCP3208; DIP-16_W7.62mm

Connections:
CONN_LED_5V: C37.2, U12.15 (VREF), U12.16 (VDD); also elsewhere on the board
CONN_LED_12V: D27.1 (K), D28.1 (K), D29.1 (K), D30.1 (K), D31.1 (K), D32.1 (K), D33.1 (K), D34.1 (K), D35.1 (K), J14.1, J14.2, J15.2; also elsewhere on the board
CONN_LED_SAFTEY: R58.1; also elsewhere on the board
CS_ADC: U12.10 (nCS); also elsewhere on the board
CTL_CHECK: R82.1; also elsewhere on the board
CTL_CLOSE: R60.1; also elsewhere on the board
CTL_DUMP: R84.1; also elsewhere on the board
CTL_FILL: R74.1; also elsewhere on the board
CTL_IGNITOR: R76.1; also elsewhere on the board
CTL_O2: R65.1; also elsewhere on the board
CTL_OPEN: R86.1; also elsewhere on the board
CTL_PURGE: R68.1; also elsewhere on the board
CTL_SHIFT: R64.1; also elsewhere on the board
GND: C37.1, Q4.2 (S), R59.1, R61.1, R63.1, R66.1, R67.1, R69.1, R71.1, R73.1, R75.1, R77.1, R79.1, R81.1, R83.1, R85.1, R87.1, R89.1, R91.1, R93.1, U12.9 (DGND), U12.14 (AGND); also elsewhere on the board
unnamed: Q4.1 (G), R58.2, R59.2
unnamed: Q5.1 (G), R60.2, R61.2
unnamed: Q6.1 (G), R64.2, R66.2
unnamed: Q7.1 (G), R65.2, R67.2
unnamed: Q8.1 (G), R68.2, R69.2
unnamed: Q9.1 (G), R74.2, R75.2
unnamed: Q10.1 (G), R76.2, R77.2
unnamed: Q11.1 (G), R82.2, R83.2
unnamed: Q12.1 (G), R84.2, R85.2
unnamed: Q13.1 (G), R86.2, R87.2
SAFETY_12V: Q4.3 (D), Q5.2 (S), Q6.2 (S), Q7.2 (S), Q8.2 (S), Q9.2 (S), Q10.2 (S), Q11.2 (S), Q12.2 (S), Q13.2 (S)
SPI_MISO: U12.12 (DOUT); also elsewhere on the board
SPI_MOSI: U12.11 (DIN); also elsewhere on the board
SPI_SCK: U12.13 (CLK); also elsewhere on the board
SV_CHECK: D33.2 (A), J16.6, Q11.3 (D), R88.2
SV_CLOSE: D27.2 (A), J16.7, Q5.3 (D), R62.2
SV_DUMP: D34.2 (A), J16.1, Q12.3 (D), R90.2
SV_FILL: D31.2 (A), J16.2, Q9.3 (D), R78.2
SV_IGNITOR: D32.2 (A), J15.1, Q10.3 (D), R80.2
SV_O2: D29.2 (A), J16.3, Q7.3 (D), R70.2
SV_OPEN: D35.2 (A), J16.5, Q13.3 (D), R92.2
SV_PURGE: D30.2 (A), J16.8, Q8.3 (D), R72.2
SV_SHIFT: D28.2 (A), J16.4, Q6.3 (D)
VREF_CHECK: R88.1, R89.2, U12.7 (CH6)
VREF_CLOSE: R62.1, R63.2, U12.6 (CH5)
VREF_DUMP: R90.1, R91.2, U12.2 (CH1)
VREF_FILL: R78.1, R79.2, U12.3 (CH2)
VREF_IGNITOR: R80.1, R81.2, U12.1 (CH0)
VREF_O2: R70.1, R71.2, U12.4 (CH3)
VREF_OPEN: R92.1, R93.2, U12.5 (CH4)
VREF_PURGE: R72.1, R73.2, U12.8 (CH7)

Parts:
J7: CONN_STATUS_PANEL; DF51A-14DP-2DS; Digikey_PN 2946-2601-3104-ND
J8: CONN_PANEL_BOARD_2; DF51A-22DP-2DS; Digikey_PN 2946-2601-3104-ND

Connections:
7SEG_CLK: J7.5; also elsewhere on the board
7SEG_DIO: J7.6; also elsewhere on the board
CONN_LED_5V: J7.10, J7.14, J8.22; also elsewhere on the board
CONN_LED_12V: J7.11; also elsewhere on the board
CONN_LED_CHECK: J8.18; also elsewhere on the board
CONN_LED_COM: J7.9; also elsewhere on the board
CONN_LED_ERROR: J7.3; also elsewhere on the board
CONN_LED_FB_CHECK: J8.11
CONN_LED_INPUT: J7.12; also elsewhere on the board
CONN_LED_LOW_VOLTAGE: J7.2; also elsewhere on the board
CONN_LED_RS485_ACCESS: J7.4; also elsewhere on the board
CONN_LED_SAFTEY: J8.20; also elsewhere on the board
CONN_LED_TASK: J7.8; also elsewhere on the board
CONN_LED_USB_ACCESS: J7.7; also elsewhere on the board
CTL_CHECK: J8.21; also elsewhere on the board
CTL_KILL: J8.8; also elsewhere on the board
CTL_RESET: J7.13; also elsewhere on the board
CTL_RUN: J8.10; also elsewhere on the board
CTL_SAFETY: J8.19; also elsewhere on the board
GND: J7.1, J8.1; also elsewhere on the board

Parts:
R55, R56, R57: 1kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Digikey_PN 2019-RK73H1JTTD1001FCT-ND
SW1: RUN_SW; SKRPACE010
SW2: KILL_SW; SKRPACE010
SW3: SAFETY_SW; PinHeader_1x02_P2.54mm_Vertical
SW4: RESET_SW; SKRPACE010
SW5: CHECK_SW; PinHeader_1x02_P2.54mm_Vertical

Connections:
CONN_LED_5V: R57.2, SW2.1, SW2.2, SW5.1 (A); also elsewhere on the board
CTL_CHECK: R56.1, SW5.2 (B); also elsewhere on the board
CTL_KILL: R55.1, SW2.3 (K), SW2.4 (A); also elsewhere on the board
CTL_RESET: SW4.3 (K), SW4.4 (A); also elsewhere on the board
CTL_RUN: SW1.3 (K), SW1.4 (A); also elsewhere on the board
CTL_SAFETY: R57.1, SW3.2 (B); also elsewhere on the board
GND: R55.2, R56.2, SW1.1, SW1.2, SW3.1 (A), SW4.1, SW4.2; also elsewhere on the board

Notes on the sheet:
KILL SWITCH A MOM +
RUN SWITCH A MOM +
CHECK SWITCH A ALT +
RESET SWITCH A MOM -
SAFETY SWITCH A ALT -

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
Board: 2 copper layers, 150.0 x 100.0 mm, 225 parts (0 on the bottom side), 149 nets.

## KiCad design KiCad/LaunchController2.0/LaunchController2.0.kicad_pcb

Parts:
C1, C2: 15pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3, C4, C5, C6, C7, C8, C10, C11: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C9: 10nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; Digikey_PN 490-GCM21B5C2E103FX0ALCT-ND
D1: GS1010FL; D_SOD-123F
D2: LED_O; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; Digikey_PN SML-D15DWT86CCT-ND
F1: MF-NSMF050; Fuse_1206_3216Metric_Pad1.42x1.75mm_HandSolder
H1, H2, H3, H4: MountingHole; MountingHole_4.3mm_M4_Pad_Via
J1: CONN_ICSP; PinHeader_1x06_P2.54mm_Vertical
J2: CONN_USB; TerminalBlock_WAGO_2601-3104_1x04_P3.50mm_Vertical; Digikey_PN 2946-2601-3104-ND
J3: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
L1: 10uH; L_1210_3225Metric_Pad1.42x2.65mm_HandSolder
R1, R2, R5, R6, R8, R13: 1kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Digikey_PN 2019-RK73H1JTTD1001FCT-ND
R3, R7, R9: 10kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Digikey_PN 2019-RK73H1JTTD1002FCT-ND
R4: 1MR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Digikey_PN 2019-RK73H1JTTD1004FCT-ND
R10: 1MR; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder; Digikey_PN 2019-RK73H2BTTD1004FCT-ND
R11, R12: 5.1kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Digikey_PN 2019-RK73H1JTTD5101FCT-ND
U1: ATmega2560-16A; TQFP-100_14x14mm_P0.5mm
U2: FT232RNL; SSOP-28_5.3x10.2mm_P0.65mm
U3: USBLC6-2SC6Y; SOT-23-6; Digikey_PN 497-11882-1-ND
Y1: HUSG-16.000-20; Crystal_HC49-4H_Vertical

Connections:
7SEG_CLK: U1.89 (PK0); also elsewhere on the board
7SEG_DIO: U1.88 (PK1); also elsewhere on the board
CONN_LED_5V: C4.1, C5.1, C6.1, C10.2, D1.1 (K), J1.5, L1.2, R3.1, R7.1, R9.1, U1.10 (VCC), U1.31 (VCC), U1.61 (VCC), U1.80 (VCC), U2.4 (VCCIO), U2.20 (VCC); also elsewhere on the board
CONN_LED_CLOSE: U1.23 (PB4); also elsewhere on the board
CONN_LED_COM: U1.84 (PK5); also elsewhere on the board
CONN_LED_DUMP: U1.24 (PB5); also elsewhere on the board
CONN_LED_EMERGENCY: U1.29 (PG4); also elsewhere on the board
CONN_LED_ERROR: U1.83 (PK6); also elsewhere on the board
CONN_LED_FILL: U1.19 (PB0); also elsewhere on the board
CONN_LED_IGNITOR: U1.16 (PH4); also elsewhere on the board
CONN_LED_LOW_VOLTAGE: U1.82 (PK7); also elsewhere on the board
CONN_LED_O2: U1.39 (PL4); also elsewhere on the board
CONN_LED_OPEN: U1.18 (PH6); also elsewhere on the board
CONN_LED_PURGE: U1.25 (PB6); also elsewhere on the board
CONN_LED_RS485_ACCESS: U1.74 (PA4); also elsewhere on the board
CONN_LED_SAFTEY: U1.27 (PH7); also elsewhere on the board
CONN_LED_SEQUENCE: U1.28 (PG3); also elsewhere on the board
CONN_LED_SHIFT: U1.17 (PH5); also elsewhere on the board
CONN_LED_TASK: U1.85 (PK4); also elsewhere on the board
CONN_LED_USB_ACCESS: U2.22 (CBUS1); also elsewhere on the board
CTL_CLOSE: U1.51 (PG0); also elsewhere on the board
CTL_CONFIRM_1: U1.60 (PC7); also elsewhere on the board
CTL_CONFIRM_2: U1.59 (PC6); also elsewhere on the board
CTL_CONFIRM_3: U1.58 (PC5); also elsewhere on the board
CTL_DUMP: U1.52 (PG1); also elsewhere on the board
CTL_EMERGENCY_STOP: U1.57 (PC4); also elsewhere on the board
CTL_FILL: U1.48 (PD5); also elsewhere on the board
CTL_IGNITOR: U1.50 (PD7); also elsewhere on the board
CTL_KILL: U1.64 (PJ1); also elsewhere on the board
CTL_O2: U1.54 (PC1); also elsewhere on the board
CTL_OPEN: U1.49 (PD6); also elsewhere on the board
CTL_POWER: U1.92 (PF5); also elsewhere on the board
CTL_PURGE: U1.53 (PC0); also elsewhere on the board
CTL_RESET: C11.2, D1.2 (A), J1.2, R3.2, U1.30 (~RESET); also elsewhere on the board
CTL_RS485_DERE: U1.76 (PA2); also elsewhere on the board
CTL_SAFETY: U1.55 (PC2); also elsewhere on the board
CTL_SEQUENCE_START: U1.56 (PC3); also elsewhere on the board
CTL_SHIFT: U1.47 (PD4); also elsewhere on the board
GND: C1.1, C2.1, C3.1, C4.2, C5.2, C6.2, C7.2, C8.1, C9.1, C10.1, J1.1, J2.1, J3.A1 (GND), J3.A12 (GND), J3.B1 (GND), J3.B12 (GND), R8.2, R10.2, R11.2, R12.2, R13.2, U1.11 (GND), U1.32 (GND), U1.62 (GND), U1.81 (GND), U1.99 (GND), U2.7 (GND), U2.18 (GND), U2.21 (GND), U2.25 (AGND), U2.26 (TEST), U3.2 (GND); also elsewhere on the board
GNDPWR: C9.2, J3.S1 (SHIELD), R10.1
I2C_SCL: R7.2, U1.43 (PD0); also elsewhere on the board
I2C_SDA: R9.2, U1.44 (PD1); also elsewhere on the board
LED_USB_TXLED: U2.23 (CBUS0); also elsewhere on the board
unnamed: D2.2 (A), U1.26 (PB7)
unnamed: D2.1 (K), R8.1
unnamed: F1.1, J3.A4 (VBUS), J3.A9 (VBUS), J3.B4 (VBUS), J3.B9 (VBUS)
unnamed: J3.A5 (CC1), R11.1
unnamed: J3.B5 (CC2), R12.1
unnamed: J3.A6 (D+), J3.B6 (D+), U3.3 (I/O2)
unnamed: J3.A7 (D-), J3.B7 (D-), U3.1 (I/O1)
unnamed: C3.2, U1.98 (AREF)
unnamed: C7.1, L1.1, U1.100 (AVCC)
unnamed: R5.1, U1.2 (PE0)
unnamed: R6.2, U1.3 (PE1)
unnamed: R1.2, U1.12 (PH0)
unnamed: R2.2, U1.13 (PH1)
unnamed: C1.2, R4.1, U1.34 (XTAL1), Y1.2
unnamed: C2.2, R4.2, U1.33 (XTAL2), Y1.1
unnamed: C8.2, U2.17 (3V3OUT)
unnamed: C11.1, R13.1, U2.2 (DTR)
SPI_MISO: J1.6, U1.22 (PB3)
SPI_MOSI: J1.3, U1.21 (PB2)
SPI_SCK: J1.4, U1.20 (PB1)
UART0_RX: R5.2, U2.1 (TXD)
UART0_TX: R6.1, U2.5 (RXD)
UART1_RX: U1.45 (PD2); also elsewhere on the board
UART1_TX: U1.46 (PD3); also elsewhere on the board
UART2_RX: R1.1; also elsewhere on the board
UART2_TX: R2.1; also elsewhere on the board
USB_D+: J2.2, U2.15 (USBD+), U3.4 (I/O2)
USB_D-: J2.3, U2.16 (USBD-), U3.6 (I/O1)
USB_VBUS: F1.2, J2.4, U3.5 (VBUS); also elsewhere on the board
VREF_THERMISTOR: U1.93 (PF4); also elsewhere on the board

Notes on the sheet:
CONNECTION ICSP
USB-Serial
配線（符号）に気をつけよう
CONNECTION USB

Parts:
C26, C27, C33, C34: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C28, C29, C32, C35: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C30, C31: 470pF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder; Digikey_PN 445-5785-1-ND
D5: GS1010FL; D_SOD-123F
FB1, FB2: 2kR@100MHz; L_0603_1608Metric_Pad1.05x0.95mm_HandSolder; Digikey_PN 445-MMZ1608S202ATA00CT-ND
J11: CONN_AUDIO; TerminalBlock_WAGO_2601-3102_1x02_P3.50mm_Vertical; Digikey_PN 2946-2601-3102-ND
J12: CONN_SPEAKER; TerminalBlock_WAGO_2601-3102_1x02_P3.50mm_Vertical; Digikey_PN 2946-2601-3102-ND
J13: Conn_01x08
J14: CONN_RS485; TerminalBlock_WAGO_2601-3104_1x04_P3.50mm_Vertical; Digikey_PN 2946-2601-3104-ND
R43: 120R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; Digikey_PN 2019-RK73H2ATTD1200FCT-ND
R44: TestPoint_A; R_0805_2012Metric
R45: TestPoint_B; R_0805_2012Metric
U8: DFPlayer; DFPlayer-mini
U9: ADM2587EBRWZ; SOIC-20W_7.5x12.8mm_P1.27mm
U10: 24LC256; DIP-8_W7.62mm

Connections:
/Peripheral/Visoin: C32.2, C33.2, C34.2, FB1.2, U9.19 (Visoin)
/Peripheral/Visoout: C35.2, FB1.1, U9.12 (Visoout)
CONN_LED_5V: C26.2, C27.2, C28.2, C29.2, D5.2 (A), U9.2 (VCC), U9.8 (VCC), U10.8 (VCC); also elsewhere on the board
CTL_RS485_DERE: U9.5 (~RE), U9.6 (DE); also elsewhere on the board
GND: C26.1, C27.1, C28.1, C29.1, C30.1, J11.1, U8.7 (GND), U8.10 (GND), U9.1 (GND1), U9.3 (GND1), U9.9 (GND1), U9.10 (GND1), U10.1 (A0), U10.2 (A1), U10.3 (A2), U10.4 (GND), U10.7 (WP); also elsewhere on the board
GND2: C31.2, C32.1, C33.1, C34.1, C35.1, FB2.1, FB2.2, J14.1, J14.4, U9.11 (GND2), U9.14 (GND2), U9.16 (GND2), U9.20 (GND2)
I2C_SCL: U10.6 (SCL); also elsewhere on the board
I2C_SDA: U10.5 (SDA); also elsewhere on the board
unnamed: C30.2, C31.1
unnamed: D5.1 (K), U8.1 (VCC)
unnamed: J11.2, U8.5 (DAC_L)
unnamed: J12.1, U8.8 (SPK1)
unnamed: J12.2, U8.6 (SPK2)
unnamed: J14.2, R44.1
unnamed: J14.3, R45.2
unnamed: R43.2, R44.2, U9.13 (Y), U9.18 (A)
unnamed: R43.1, R45.1, U9.15 (Z), U9.17 (B)
UART1_RX: U9.4 (RxD); also elsewhere on the board
UART1_TX: U9.7 (TxD); also elsewhere on the board
UART2_RX: U8.3 (TX); also elsewhere on the board
UART2_TX: U8.2 (RX); also elsewhere on the board

Notes on the sheet:
ISOLATED RS485
AUDIO
丸ピンICソケット（BOM用）
EEPROM

Parts:
R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28: 1kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Digikey_PN 2019-RK73H1JTTD1001FCT-ND
SW1, SW2, SW3: SW_Push; SKRPACE010
SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17: SW_Push; PinHeader_1x02_P2.54mm_Vertical

Connections:
CONN_LED_5V: SW2.1, SW2.2, SW4.1, SW5.1, SW6.1, SW7.1, SW8.1, SW9.1, SW10.1, SW11.1, SW12.1, SW13.1, SW14.1, SW15.1, SW16.1, SW17.1; also elsewhere on the board
CTL_CLOSE: R27.1, SW16.2; also elsewhere on the board
CTL_CONFIRM_1: R18.1, SW7.2; also elsewhere on the board
CTL_CONFIRM_2: R19.1, SW8.2; also elsewhere on the board
CTL_CONFIRM_3: R20.1, SW9.2; also elsewhere on the board
CTL_DUMP: R23.1, SW12.2; also elsewhere on the board
CTL_EMERGENCY_STOP: R17.1, SW6.2; also elsewhere on the board
CTL_FILL: R22.1, SW11.2; also elsewhere on the board
CTL_IGNITOR: R25.1, SW14.2; also elsewhere on the board
CTL_KILL: R14.1, SW2.3 (K), SW2.4 (A); also elsewhere on the board
CTL_O2: R24.1, SW13.2; also elsewhere on the board
CTL_OPEN: R26.1, SW15.2; also elsewhere on the board
CTL_PURGE: R28.1, SW17.2; also elsewhere on the board
CTL_RESET: SW3.3 (K), SW3.4 (A); also elsewhere on the board
CTL_RUN: SW1.3 (K), SW1.4 (A); also elsewhere on the board
CTL_SAFETY: R15.1, SW4.2; also elsewhere on the board
CTL_SEQUENCE_START: R16.1, SW5.2; also elsewhere on the board
CTL_SHIFT: R21.1, SW10.2; also elsewhere on the board
GND: R14.2, R15.2, R16.2, R17.2, R18.2, R19.2, R20.2, R21.2, R22.2, R23.2, R24.2, R25.2, R26.2, R27.2, R28.2, SW1.1, SW1.2, SW3.1, SW3.2; also elsewhere on the board

Notes on the sheet:
SEQUENCE START SWITCH A MOM +
OPEN SWITCH A ALT +
SHIFT SWITCH A ALT +
SAFETY SWITCH A ALT +
O2 SWITCH A ALT +
CLOSE SWITCH A ALT +
CONFIRM 3 SWITCH A ALT +
KILL SWITCH A MOM +
RESET SWITCH A MOM -
PURGE SWITCH A ALT +
RUN SWITCH A MOM +
FILL SWITCH A MOM +
IGNITOR SWITCH A ALT +
CONFIRM 2 SWITCH A ALT +
EMERGENCY STOP SWITCH A ALT +
CONFIRM 1 SWITCH A ALT +
DUMP SWITCH A ALT +
