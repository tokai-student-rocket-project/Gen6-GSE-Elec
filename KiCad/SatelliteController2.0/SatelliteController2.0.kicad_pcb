# Repository tokai-student-rocket-project/Gen6-GSE-Elec

File README.md:

# 第6世代 Ground Support Equipment (GSE)

**2025年3月8日，H-60号機打上げ実験にて運用をし正常に動作したことを確認しました．**

## システムの特徴
- 従来の大型電源をやめてバッテリー駆動にし，小型軽量化しました．フィールドでの運用が楽になります．
- Arduino で記述し，PlatformIO で開発しています．コードは機能ごとにモジュールに分けてあり，外部ライブラリは PlatformIO が自動で管理します．
- VESIM10 圧力センサと ADS1115 ADC で N2O の圧力を高精度にリアルタイム計測し，離れた場所から監視できます．
- セミオートマチックシーケンスと緊急停止 (E-STOP) 機能があり，フェールセーフと安全インターロックを組み込んでいます．

## バージョン履歴
| バージョン | 主な特徴・追加機能 | ソースファイル | PlatformIO 環境名 |
|---|---|---|---|
| Gen6 1.0 | 初代．2025年3月8日 H-60号機打上げ実験で運用．RS485有線通信，セミオートシーケンス | `src/LaunchController/`<br>`src/SatelliteController/` | `[env:Launch]`<br>`[env:Satellite]` |
| Gen6 2.0 | 安全性と安定性を強化．電磁弁故障検出のデバウンス，リミットスイッチによる安全ゲートの監視，ゼロ点校正時の安全判定を追加し，通信アルゴリズムを見直し | `src/LaunchController2.0/`<br>`src/SatelliteController2.0/` | `[env:Launch2]`<br>`[env:Satellite2]` |

## ギャラリー
- [2025年3月8日 H-60号機打上げ実験](https://github.com/tokai-student-rocket-project/Gen6-GSE-Elec/blob/main/Documents/Pictures/Gallery/Gallery.md)

## ドキュメント
- [仕様](./Documents/Manuals/Specification.md)
- [GSE運用マニュアル](./Documents/Manuals/Gen6GSEManual-Elec.md)
- [パーツリスト](./Documents/Development/PartsList.xlsx)
- [自動シークエンスタイミングの考え方](./Documents/Software/AutoSequence.md)
- [通信・タスク管理ライブラリについて](./Documents/Software/library_guide.md)
- [亜酸化窒素の圧力計測について](./Documents/Sensor/VESIM10_Manual.md)
  - [校正シート](./Documents/Sensor/VESIM10_Calibration.xlsx)
  - [試験成績表(TSRP Only)](https://u-tokai.box.com/s/f19nbcfg3vuwrdxsdca0jw9x3lm8z8kp)
- [各種ドキュメント一覧・目次](./Documents/README.md)

## フォルダ構成

```
Gen6-GSE-Elec/
├── Documents/        # 資料保管場所．できる限りの情報を残せるように頑張ります．
├── include/          # 特に使用していません．(PlatformIO自動生成)
├── KiCad/            # サテライトコントローラーとランチコントローラーの基板 (KiCad 10.0)
├── lib/              # ライブラリ．新しく作成する際はここに置くと分かりやすいです．(PlatformIO自動生成)
├── src/              # ランチコントローラーとサテライトコントローラーのソースファイル (PlatformIO自動生成)
├── test/             # test機能を使っていないので意味はありません．(PlatformIO自動生成)
├── LICENSE           # ライセンス
└── platformio.ini    # PlatformIOの設定ファイル
```

- 基板はオープンソースのEDAである[KiCad](https://www.kicad.org/)で作成しました．(開発中に KiCad 8.0 → KiCad 10.0 となりました．)
- ソースはArduinoで記述していますが，[PlatformIO](https://platformio.org/)の仕様上 .ino ファイルではなく .cpp ファイルになっています．
- platformio.ini の中身は[platform.iniについて](#platforminiについて)を参照してください．

## platformio.iniについて

[platformio.ini](./platformio.ini) はPlatformIOを使用するための設定ファイルです．外部ライブラリがインストールされていなくてもこのファイルに記載があれば自動的にインストールしてくるため環境構築を行いやすくなり，とても便利です．参照：[公式](https://docs.platformio.org/en/latest/projectconf/index.html)

platformio.iniファイルにはセクションがあり，それぞれに対してKeyとValueのペアがあります．ここでは安定版である 1.0 と 2.0 の環境だけを説明します．3.0 やデモ用・デバッグ用の環境については platformio.ini 内のコメントを見てください．

> [!NOTE]
> ここの説明を読むより，[公式](https://docs.platformio.org/en/latest/projectconf/index.html)の説明を読んだ方が正確で分かりやすいです！

| 環境名 | バージョン | 対象 | ソースファイル |
|---|---|---|---|
| `Satellite` | 1.0 | サテライトコントローラー | `src/SatelliteController/SatelliteController.cpp` |
| `Launch` | 1.0 | ランチコントローラー | `src/LaunchController/LaunchController.cpp` |
| `Satellite2` | 2.0 | サテライトコントローラー | `src/SatelliteController2.0/SatelliteController2.0.cpp` |
| `Launch2` | 2.0 | ランチコントローラー | `src/LaunchController2.0/LaunchController2.0.cpp` |

ビルドと書き込みは `pio run -e Satellite2 -t upload` のように環境名を指定して行います．

### 共通設定
[env]
> 名前のない `[env]` はすべての環境に共通の設定です．各環境で `lib_deps` を書くとこちらは上書きされるため，2.0 では `${env.lib_deps}` で読み込んでから追加のライブラリを書いています．

lib_deps = hideakitai/TaskManager, hideakitai/MsgPacketizer
> 通信とタスク管理に使うライブラリです．詳しくは[通信・タスク管理ライブラリについて](./Documents/Software/library_guide.md)を参照してください．

### 1.0 サテライトコントローラー
[env:Satellite]
> 環境を示しています．今回はサテライトコントローラーの環境になります．

platform = atmelavr
> 使用するマイコンに合わせています．参照：[公式](https://docs.platformio.org/en/latest/projectconf/sections/env/options/platform/platform.html)

board = ATmega2560
> 使用するマイコンが持つ固有の値を入れています．参照：[公式](https://docs.platformio.org/en/latest/projectconf/sections/env/options/platform/board.html)

framework = arduino
> 使用したいフレームワークを指定しています．参照：[公式](https://docs.platformio.org/en/latest/frameworks/index.html#frameworks)

monitor_speed = 115200
> シリアルモニターのボーレートを指定しています．なお，VScodeの拡張機能である Serial Monitor を使用する場合は拡張機能側で設定する必要があるため関係ありません．

upload_protocol = arduinoisp
> ArduinoISP を使用して書き込むため指定しています．（シリアル変換ICの影響か，USB経由で書き込みができなかったため．つけていて良かった．）

upload_speed = 19200
upload_flags = ...
upload_command = avrdude $UPLOAD_FLAGS -U flash:w:$SOURCE:i
> ArduinoISP 周りの設定です．avrdude を stk500v1 として 19200bps で動かして書き込んでいます．

lib_deps = ...
> 外部ライブラリを指定しています．Adafruit INA219，Mcp320x，TaskManager，CRCx，MsgPack，MsgPacketizer の6つです．

build_src_filter = +<SatelliteController/SatelliteController.cpp>
> env:Satellite の環境に書き込みたいソースファイルを指定できます．

build_flags = ...
> ライブラリの上限値をマクロで変更しています．値は[build_flags の値](#build_flags-の値)にまとめています．

### 1.0 ランチコントローラー
[env:Launch]
> ランチコントローラーの環境です．`platform`，`board`，`framework`，`monitor_speed`，`lib_deps` は[1.0 サテライトコントローラー](#10-サテライトコントローラー)と同じです．

build_src_filter = +<LaunchController/LaunchController.cpp>
> 書き込むソースファイルです．

> [!NOTE]
> サテライトコントローラーと違い `upload_protocol` などの ArduinoISP 関連の設定はないため，通常どおり USB 経由で書き込みます．

### 2.0 サテライトコントローラー
[env:Satellite2]
> `platform`，`board`，`framework`，`monitor_speed` は 1.0 と同じです．ArduinoISP の設定はないので USB 経由で書き込みます．

lib_deps = ${env.lib_deps}, Adafruit INA219, Mcp320x, Adafruit ADS1X15
> 共通ライブラリに加えて，N2O の圧力計測で使う ADS1115 のために Adafruit ADS1X15 を追加しています．

build_src_filter = +<SatelliteController2.0/SatelliteController2.0.cpp>

### 2.0 ランチコントローラー
[env:Launch2]
> `platform`，`board`，`framework`，`monitor_speed` は 1.0 と同じです．

lib_deps = ${env.lib_deps}, Adafruit INA219, Mcp320x

build_src_filter = +<LaunchController2.0/LaunchController2.0.cpp>

> [!WARNING]
> `Launch2_demo` は `Launch2` に `DEMO_MODE` を付けたシーケンス確認用の環境です．現場運用のファームウェアには絶対に使わないでください．

### build_flags の値
MsgPacketizer と TaskManager は内部のキューや配列の大きさが固定なので，subscribe やタスクを増やしたときはここの値も増やす必要があります．

| マクロ | 内容 | Satellite | Launch | Satellite2 | Launch2 |
|---|---|---|---|---|---|
| `PACKETIZER_MAX_CALLBACK_QUEUE_SIZE` | subscribe できる数 | 12 | 12 | 12 | 12 |
| `PACKETIZER_MAX_STREAM_MAP_SIZE` | 登録できるストリーム数 (Serial1 + Serial) | 4 | 4 | - | - |
| `MSGPACK_MAX_ARRAY_SIZE` | 配列の要素数 | - | 12 | - | - |
| `ARX_VECTOR_DEFAULT_SIZE` | メインタスク数の上限 | 20 | 20 | 25 | 25 |
| `TASKMANAGER_MAX_SUBTASKS` | サブタスク数の上限 | 8 | 8 | 8 | 8 |

`-` は指定なし（ライブラリの既定値）です．

### 手順書
- [せいさくちゅう](./)

### データフロー

- [ランチコントローラー](./Documents/Pictures/DataFlowDiagram/LaunchController_DataFlowDiagram.png)

- [サテライトコントローラー](./Documents/Pictures/DataFlowDiagram/SatelliteController_DataFlowDiagram.png)

## License

Copyright (c) 2025 Tokai Student Rocket Project

This project is licensed under the MIT License. See the [LICENSE](https://github.com/tokai-student-rocket-project/Gen6-GSE-Elec/blob/main/LICENSE) file for more details.

## KiCad design KiCad/SatelliteController2.0/SatelliteController2.0.kicad_pcb

Parts:
C1, C2: 15pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3, C4, C5, C6, C7, C8, C10, C11: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C9: 10nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; Digikey_PN 490-GCM21B5C2E103FX0ALCT-ND
D1: GS1010FL; D_SOD-123F
D2: LED_O; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; Digikey_PN SML-D15DWT86CCT-ND
F1: MF-NSMF050; Fuse_1206_3216Metric_Pad1.42x1.75mm_HandSolder
H1, H2, H3, H4: MountingHole; MountingHole_4.3mm_M4_Pad_Via
J1: CONN_ICSP; PinHeader_1x06_P2.54mm_Vertical
J2: CONN_USB; TerminalBlock_WAGO_2601-3104_1x04_P3.50mm_Vertical; Digikey_PN 2946-2601-3104-ND
J3: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
L1: 10uH; L_1210_3225Metric_Pad1.42x2.65mm_HandSolder
R1, R5, R7, R8: 10kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Digikey_PN 2019-RK73H1JTTD1002FCT-ND
R2: 1MR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Digikey_PN 2019-RK73H2BTTD1004FCT-ND
R3, R4, R6, R12: 1kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Digikey_PN 2019-RK73H1JTTD1001FCT-ND
R9: 1MR; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder; Digikey_PN 2019-RK73H2BTTD1004FCT-ND
R10, R11: 5.1kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Digikey_PN 2019-RK73H1JTTD5101FCT-ND
S1: SLDR PASTE NO-CLN SAC305 50G; Digikey_PN SMD291SNL50T3-ND
U1: ATMEGA2560-16AUR; TQFP-100_14x14mm_P0.5mm
U2: FT232RNL; SSOP-28_5.3x10.2mm_P0.65mm
U3: USBLC6-2SC6; SOT-23-6; Digikey_PN 497-5235-1-ND
Y1: HUSG-16.000-20; Crystal_HC49-4H_Vertical

Connections:
7SEG_CLK: U1.89 (PK0); also elsewhere on the board
7SEG_DIO: U1.88 (PK1); also elsewhere on the board
ALERT/RDY: U1.40 (PL5); also elsewhere on the board
CONN_LED_5V: C4.1, C5.1, C6.1, C10.2, D1.1 (K), J1.5, L1.2, R1.1, R5.1, R7.1, R8.1, U1.10 (VCC), U1.31 (VCC), U1.61 (VCC), U1.80 (VCC), U2.4 (VCCIO), U2.20 (VCC); also elsewhere on the board
CONN_LED_CHECK: U1.25 (PB6); also elsewhere on the board
CONN_LED_COM: U1.84 (PK5); also elsewhere on the board
CONN_LED_ERROR: U1.83 (PK6); also elsewhere on the board
CONN_LED_LOW_VOLTAGE: U1.82 (PK7); also elsewhere on the board
CONN_LED_RS485_ACCESS: U1.57 (PC4); also elsewhere on the board
CONN_LED_SAFTEY: U1.28 (PG3); also elsewhere on the board
CONN_LED_TASK: U1.85 (PK4); also elsewhere on the board
CONN_LED_USB_ACCESS: U2.22 (CBUS1); also elsewhere on the board
CS_ADC: R5.2, U1.58 (PC5); also elsewhere on the board
CTL_CHECK: U1.29 (PG4), U1.54 (PC1); also elsewhere on the board
CTL_CLOSE: U1.53 (PC0); also elsewhere on the board
CTL_DUMP: U1.49 (PD6); also elsewhere on the board
CTL_FILL: U1.50 (PD7); also elsewhere on the board
CTL_IGNITOR: U1.48 (PD5); also elsewhere on the board
CTL_KILL: U1.64 (PJ1); also elsewhere on the board
CTL_O2: U1.51 (PG0); also elsewhere on the board
CTL_OPEN: U1.52 (PG1); also elsewhere on the board
CTL_POWER: U1.92 (PF5); also elsewhere on the board
CTL_PURGE: U1.55 (PC2); also elsewhere on the board
CTL_RESET: C11.2, D1.2 (A), J1.2, R1.2, U1.30 (~RESET); also elsewhere on the board
CTL_RS485_DERE: U1.56 (PC3); also elsewhere on the board
CTL_SAFETY: U1.27 (PH7); also elsewhere on the board
CTL_SHIFT: U1.47 (PD4); also elsewhere on the board
FLIGHT_MODE: U1.42 (PL7); also elsewhere on the board
GND: C1.1, C2.2, C3.1, C4.2, C5.2, C6.2, C7.2, C8.1, C9.1, C10.1, J1.1, J2.1, J3.A1 (GND), J3.A12 (GND), J3.B1 (GND), J3.B12 (GND), R6.2, R9.2, R10.2, R11.2, R12.2, U1.11 (GND), U1.32 (GND), U1.62 (GND), U1.81 (GND), U1.99 (GND), U2.7 (GND), U2.18 (GND), U2.21 (GND), U2.25 (AGND), U2.26 (TEST), U3.2 (GND); also elsewhere on the board
GNDPWR: C9.2, J3.S1 (SHIELD), R9.1
I2C_SCL: R7.2, U1.43 (PD0); also elsewhere on the board
I2C_SDA: R8.2, U1.44 (PD1); also elsewhere on the board
LED_FB_SHIFT: U1.17 (PH5)
LED_USB_TXLED: U2.23 (CBUS0); also elsewhere on the board
unnamed: D2.2 (A), U1.26 (PB7)
unnamed: D2.1 (K), R6.1
unnamed: F1.1, J3.A4 (VBUS), J3.A9 (VBUS), J3.B4 (VBUS), J3.B9 (VBUS)
unnamed: J3.A5 (CC1), R10.1
unnamed: J3.B5 (CC2), R11.1
unnamed: J3.A6 (D+), J3.B6 (D+), U3.3 (I/O2)
unnamed: J3.A7 (D-), J3.B7 (D-), U3.1 (I/O1)
unnamed: C3.2, U1.98 (AREF)
unnamed: C7.1, L1.1, U1.100 (AVCC)
unnamed: R3.1, U1.2 (PE0)
unnamed: R4.2, U1.3 (PE1)
unnamed: C1.2, R2.1, U1.34 (XTAL1), Y1.2
unnamed: C2.1, R2.2, U1.33 (XTAL2), Y1.1
unnamed: C8.2, U2.17 (3V3OUT)
unnamed: C11.1, R12.1, U2.2 (DTR)
SPI_MISO: J1.6, U1.22 (PB3); also elsewhere on the board
SPI_MOSI: J1.3, U1.21 (PB2); also elsewhere on the board
SPI_SCK: J1.4, U1.20 (PB1); also elsewhere on the board
UART0_RX: R3.2, U2.1 (TXD)
UART0_TX: R4.1, U2.5 (RXD)
UART1_RX: U1.45 (PD2); also elsewhere on the board
UART1_TX: U1.46 (PD3); also elsewhere on the board
USB_D+: J2.2, U2.15 (USBD+), U3.4 (I/O2)
USB_D-: J2.3, U2.16 (USBD-), U3.6 (I/O1)
USB_VBUS: F1.2, J2.4, U3.5 (VBUS); also elsewhere on the board
VALVE_MODE: U1.41 (PL6); also elsewhere on the board
VREF_N2O_PRESS: U1.87 (PK2)
VREF_THERMISTOR: U1.93 (PF4); also elsewhere on the board

Notes on the sheet:
53 PURGE↔58 CHECK
48 FILL↔52 DUMP
Satellite Controller との変更点
USB-Serial
50 IGN↔47 SHIFT
BOM用
CONNECTION ICSP
CONNECTION USB

Parts:
C26, C27, C33, C35: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C28, C29, C30, C34, C36: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C31, C32: 470pF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder; Digikey_PN 445-5785-1-ND
D5, D6: BAT43XV2; D_SOD-523
FB1, FB2: 2kR@100MHz; L_0603_1608Metric_Pad1.05x0.95mm_HandSolder; Digikey_PN 445-MMZ1608S202ATA00CT-ND
J9: CONN_N2O_PRESS; TerminalBlock_WAGO_2601-3104_1x04_P3.50mm_Vertical; Digikey_PN 2946-2601-3104-ND
J10, J12: CONN_ISOLATED_RS485_REPEATER; TerminalBlock_WAGO_2601-3104_1x04_P3.50mm_Vertical; Digikey_PN 2946-2601-3104-ND
J11: CONN_UMBILICAL; TerminalBlock_WAGO_2601-3104_1x04_P3.50mm_Vertical; Digikey_PN 2946-2601-3104-ND
J13: CONN_ISOLATED_RS485; TerminalBlock_WAGO_2601-3104_1x04_P3.50mm_Vertical; Digikey_PN 2946-2601-3104-ND
R27, R28: 10kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Digikey_PN 2019-RK73H1JTTD1002FCT-ND
R29: 100R 0.1%; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R30: 120R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; Digikey_PN 2019-RK73H2ATTD1200FCT-ND
R31: RS485_A; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R32: RS485_B; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R33, R34: 300R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Digikey_PN 2019-RK73H1JTTD3000FCT-ND
U8: ADS1115IDGS; TSSOP-10_3x3mm_P0.5mm; Digikey_PN 296-38849-1-ND
U9: ADM2587E; SOIC-20W_7.5x12.8mm_P1.27mm
U10, U11: TLP785F; DIP-4_W10.16mm

Connections:
/Periferal/Visoin: C33.2, C34.2, C35.2, FB1.2, U9.19 (Visoin)
/Periferal/Visoout: C36.2, FB1.1, U9.12 (Visoout)
ALERT/RDY: R27.1, U8.2 (ALERT/RDY); also elsewhere on the board
CONN_LED_5V: C26.2, C27.2, C28.2, C29.1, C30.2, D5.1 (K), R27.2, U8.8 (VDD), U9.2 (VCC), U9.8 (VCC); also elsewhere on the board
CONN_LED_12V: J9.4; also elsewhere on the board
CTL_RS485_DERE: U9.5 (~RE), U9.6 (DE); also elsewhere on the board
FLIGHT_MODE: R33.1; also elsewhere on the board
GND: C26.1, C27.1, C28.1, C29.2, C30.1, C31.1, D6.2 (A), J9.1, J9.3, R29.2, U8.1 (ADDR), U8.3 (GND), U9.1 (GND1), U9.3 (GND1), U9.9 (GND1), U9.10 (GND1), U10.2, U11.2; also elsewhere on the board
GND2: C32.2, C33.1, C34.1, C35.1, C36.1, FB2.1, FB2.2, J10.1, J10.4, J12.1, J12.4, J13.1, J13.4, U9.11 (GND2), U9.14 (GND2), U9.16 (GND2), U9.20 (GND2)
I2C_SCL: U8.10 (SCL); also elsewhere on the board
I2C_SDA: U8.9 (SDA); also elsewhere on the board
unnamed: C31.2, C32.1
unnamed: D5.2 (A), D6.1 (K), R28.1, U8.4 (AIN0)
unnamed: J9.2, R28.2, R29.1
unnamed: J10.2, J12.2, J13.2, R31.2
unnamed: J10.3, J12.3, J13.3, R32.2
unnamed: J11.1, U11.3
unnamed: J11.2, U11.4
unnamed: J11.3, U10.4
unnamed: J11.4, U10.3
unnamed: R33.2, U10.1
unnamed: R34.2, U11.1
unnamed: R30.2, R31.1, U9.13 (Y), U9.18 (A)
unnamed: R30.1, R32.1, U9.15 (Z), U9.17 (B)
UART1_RX: U9.4 (RxD); also elsewhere on the board
UART1_TX: U9.7 (TxD); also elsewhere on the board
VALVE_MODE: R34.1; also elsewhere on the board

Notes on the sheet:
1 GND(ISOLATED) 2 A 3 B 4 GND(ISOLATED)
UMBILICAL
N2O PRESSURE A/D CONVERTER
ISOLATED RS485

Parts:
D7, D13, D15: LED_G; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; Digikey_PN SML-D12P8WT86CCT-ND
D8, D9, D10, D12, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26: LED_O; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; Digikey_PN SML-D15DWT86CCT-ND
D11: LED_B; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; Digikey_PN SMLD12BN1WT86CT-ND
D14, D16: LED_R; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; Digikey_PN SML-D12U8WT86CCT-ND
R35, R37, R39, R40, R42, R44, R45, R46, R47, R48, R49, R50, R51, R52, R53, R54: 1kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Digikey_PN 2019-RK73H1JTTD1001FCT-ND
R36: 3.6kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Digikey_PN 2019-RK73H1JTTD3601FCT-ND
R38: 2.4kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Digikey_PN 2019-RK73H1JTTD2401FCT-ND
R41, R43: 2.2kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Digikey_PN 2019-RK73H1JTTD2201FCT-ND

Connections:
CONN_LED_5V: D7.2 (A), D9.2 (A), R40.1; also elsewhere on the board
CONN_LED_12V: R38.1; also elsewhere on the board
CONN_LED_CHECK: R54.1; also elsewhere on the board
CONN_LED_COM: R41.1; also elsewhere on the board
CONN_LED_ERROR: R42.1; also elsewhere on the board
CONN_LED_INPUT: R36.1; also elsewhere on the board
CONN_LED_LOW_VOLTAGE: R44.1; also elsewhere on the board
CONN_LED_RS485_ACCESS: R39.1; also elsewhere on the board
CONN_LED_SAFTEY: R46.1; also elsewhere on the board
CONN_LED_TASK: R43.1; also elsewhere on the board
CONN_LED_USB_ACCESS: R35.2; also elsewhere on the board
CTL_CHECK: R47.1; also elsewhere on the board
CTL_CLOSE: R50.1; also elsewhere on the board
CTL_DUMP: R52.1; also elsewhere on the board
CTL_FILL: R49.1; also elsewhere on the board
CTL_IGNITOR: R45.1; also elsewhere on the board
CTL_O2: R53.1; also elsewhere on the board
CTL_OPEN: R48.1; also elsewhere on the board
CTL_PURGE: R51.1; also elsewhere on the board
GND: D8.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), D25.1 (K), D26.1 (K); also elsewhere on the board
LED_USB_TXLED: R37.2; also elsewhere on the board
unnamed: D7.1 (K), R35.1
unnamed: D8.2 (A), R36.2
unnamed: D9.1 (K), R37.1
unnamed: D10.2 (A), R38.2
unnamed: D11.2 (A), R39.2
unnamed: D12.2 (A), R40.2
unnamed: D13.2 (A), R41.2
unnamed: D14.2 (A), R42.2
unnamed: D15.2 (A), R43.2
unnamed: D16.2 (A), R44.2
unnamed: D17.2 (A), R45.2
unnamed: D18.2 (A), R46.2
unnamed: D19.2 (A), R47.2
unnamed: D20.2 (A), R48.2
unnamed: D21.2 (A), R49.2
unnamed: D22.2 (A), R50.2
unnamed: D23.2 (A), R51.2
unnamed: D24.2 (A), R52.2
unnamed: D25.2 (A), R53.2
unnamed: D26.2 (A), R54.2

Notes on the sheet:
LED_SHIFT
LED_IGNITOR
LED_PURGE
LED_INPUT
LED_RS485_ACCESS
LED_5V
LED_CLOSE
LED_ERROR
LED_DUMP
LED_TASK
LED_SAFETY
LED_LOW_VOLTAGE
LED_USB_ACCESS
LED_O2
LED_OPEN
LED_12V
LED_FILL
LED_CHECK
LED_COM

Parts:
C12, C16, C19, C20, C21, C23, C25: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C13, C14: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C15, C17: 10uF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C18, C22, C24: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D3: GS1010FL; D_SOD-123F
D4: LED_O; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; Digikey_PN SML-D15DWT86CCT-ND
J4: TO_CONVERTER; TerminalBlock_WAGO_2601-3102_1x02_P3.50mm_Vertical; Digikey_PN 2946-2601-3102-ND
J5: FROM_CONVERTER; TerminalBlock_WAGO_2601-3102_1x02_P3.50mm_Vertical; Digikey_PN 2946-2601-3102-ND
J6: DC_IN; TerminalBlock_WAGO_2601-3102_1x02_P3.50mm_Vertical; Digikey_PN 2946-2601-3102-ND
Q1, Q3: TJ8S06M3L; TO-252-2
Q2: 2SC3325-Y; SC-59_Handsoldering
R13, R16, R17: 10kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Digikey_PN 2019-RK73H1JTTD1002FCT-ND
R14: 5.6kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Digikey_PN 2019-RK73H1JTTD5601FCT-ND
R15: 3.3kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Digikey_PN 2019-RK73H1JTTD3301FCT-ND
R18: 348kR 1%; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Digikey_PN 2019-RK73H1JTTD3483FCT-ND
R19: 100kR 1%; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Digikey_PN 2019-RK73H1JTTD1003FCT-ND
R20: 100R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Digikey_PN 2019-RK73H1JTTD1000FCT-ND
R21, R23, R24, R26: 10R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Digikey_PN 2019-RK73H1JTTD10R0FCT-ND
R22, R25: 0.1R2W; R_2816_7142Metric_Pad3.20x4.45mm_HandSolder; Digikey_PN CRM2512-FX-R100ELFCT-ND
TH1: 10kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Digikey_PN 2019-RK73H1JTTD1002FCT-ND
TP1: TP_INPUT; TestPoint_Keystone_5005-5009_Compact
TP2: TP_12V; TestPoint_Keystone_5005-5009_Compact
TP3: TP_5V; TestPoint_Keystone_5005-5009_Compact
TP4: TP_GND; TestPoint_Keystone_5005-5009_Compact
U4: TPS2116DRL; SOT-583-8; Digikey_PN 296-TPS2116DRLRCT-ND
U5: NJM7805SDL1; TO-252-2
U6, U7: INA219BIDCNT; SOT-23-8; Digikey_PN 296-27898-1-ND

Connections:
+VSW: Q3.3 (S), R21.1, R22.2
CONN_LED_5V: C18.1, C22.1, C23.1, C24.1, C25.1, D4.2 (A), R13.2, TP3.1, U4.2 (VOUT), U4.7 (VOUT), U6.4 (VS), U7.4 (VS), U7.7 (A0); also elsewhere on the board
CONN_LED_12V: C15.2, C16.2, D3.1 (K), R25.1, R26.2, TP2.1, U5.1 (IN); also elsewhere on the board
CONN_LED_INPUT: C12.1, J6.2, Q1.3 (S), R14.1, TP1.1; also elsewhere on the board
CTL_POWER: R17.1; also elsewhere on the board
CTL_RUN: Q2.3 (C), R15.2; also elsewhere on the board
FROM_CONVERTER: J5.2, R24.2, R25.2
GND: C13.2, C14.2, C15.1, C16.1, C17.1, C18.2, C19.1, C22.2, C23.2, C24.2, C25.2, J4.1, J5.1, J6.1, Q2.2 (E), R16.2, R19.1, TH1.2, TP4.1, U4.1 (GND), U5.2 (GND), U6.3 (GND), U6.7 (A0), U6.8 (A1), U7.3 (GND), U7.8 (A1); also elsewhere on the board
I2C_SCL: U6.5 (SCL), U7.5 (SCL); also elsewhere on the board
I2C_SDA: U6.6 (SDA), U7.6 (SDA); also elsewhere on the board
unnamed: D4.1 (K), R20.2
unnamed: Q1.2 (D), Q3.2 (D)
unnamed: C12.2, Q1.1 (G), Q3.1 (G), R14.2, R15.1
unnamed: Q2.1 (B), R16.1, R17.2
unnamed: R18.1, R19.2, U4.4 (PR1)
unnamed: R20.1, U4.8 (ST)
unnamed: C20.1, R21.2, U6.1 (IN+)
unnamed: C20.2, R23.1, U6.2 (IN-)
unnamed: C21.1, R24.1, U7.1 (IN+)
unnamed: C21.2, R26.1, U7.2 (IN-)
TO_CONVERTER: J4.2, R22.1, R23.2
USB_VBUS: C14.1, U4.6 (VIN2); also elsewhere on the board
VIN_5V: C13.1, C17.2, C19.2, D3.2 (A), R18.2, U4.3 (VIN1), U4.5 (MODE), U5.3 (OUT)
VREF_THERMISTOR: R13.1, TH1.1; also elsewhere on the board

Notes on the sheet:
MULTIPLEXER
THERMAL MONITOR
ノイズなど，必要に応じて実装
CURRENT MONITOR
POWER INPUT DC JACK 15-24V
LINER REGULATOR 5V
CONVERTER
LOAD SWITCH
