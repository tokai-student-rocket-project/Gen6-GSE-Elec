# Repository tokai-student-rocket-project/Gen6-GSE-Elec (continued)

## KiCad design KiCad/LaunchController2.0/LaunchController2.0.kicad_pcb (continued)

Parts:
C12, C16, C19, C20, C21, C23, C25: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C13, C14: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C15, C17: 10uF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C18, C22, C24: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D3: SS2040FL; SOD-123FL_Handsolder
D4: LED_O; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; Digikey_PN SML-D15DWT86CCT-ND
J4: TO_CONVERTER; TerminalBlock_WAGO_2601-3102_1x02_P3.50mm_Vertical; Digikey_PN 2946-2601-3102-ND
J5: FROM_CONVERTER; TerminalBlock_WAGO_2601-3102_1x02_P3.50mm_Vertical; Digikey_PN 2946-2601-3102-ND
J6: DC_IN; TerminalBlock_WAGO_2601-3102_1x02_P3.50mm_Vertical; Digikey_PN 2946-2601-3102-ND
Q1, Q3: TJ8S06M3L; TO-252-2
Q2: 2SC3325-Y; SC-59_Handsoldering
R29, R32, R33: 10kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Digikey_PN 2019-RK73H1JTTD1002FCT-ND
R30: 5.6kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Digikey_PN 2019-RK73H1JTTD5601FCT-ND
R31: 3.3kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Digikey_PN 2019-RK73H1JTTD3301FCT-ND
R34: 348kR ±1%; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Digikey_PN 2019-RK73H1JTTD3483FCT-ND
R35: 100kR ±1%; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Digikey_PN 2019-RK73H1JTTD1003FCT-ND
R36: 100R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Digikey_PN 2019-RK73H1JTTD1000FCT-ND
R37, R39, R40, R42: 10R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Digikey_PN 2019-RK73H1JTTD10R0FCT-ND
R38, R41: 0.1R2W; R_2512_6332Metric_Pad1.40x3.35mm_HandSolder; Digikey_PN CRM2512-FX-R100ELFCT-ND
TH1: 10kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Digikey_PN 2019-RK73H1JTTD1002FCT-ND
TP1: TP_INPUT; TestPoint_Keystone_5005-5009_Compact
TP2: TP_12V; TestPoint_Keystone_5005-5009_Compact
TP3: TP_5V; TestPoint_Keystone_5005-5009_Compact
TP4: TP_GND; TestPoint_Keystone_5005-5009_Compact
U4: TPS2116DRL; SOT-583-8; Digikey_PN 296-TPS2116DRLRCT-ND
U5: NJM7805SDL1; TO-252-2
U6, U7: INA219BIDCNT; SOT-23-8; Digikey_PN 296-27898-1-ND

Connections:
+VSW: Q3.3 (S), R37.1, R38.2
CONN_LED_5V: C18.1, C22.1, C23.1, C24.1, C25.1, D4.2 (A), R29.2, TP3.1, U4.2 (VOUT), U4.7 (VOUT), U6.4 (VS), U7.4 (VS), U7.7 (A0); also elsewhere on the board
CONN_LED_12V: C15.2, C16.2, D3.1 (K), R41.1, R42.2, TP2.1, U5.1 (IN); also elsewhere on the board
CONN_LED_INPUT: C12.1, J6.2, Q1.3 (S), R30.1, TP1.1; also elsewhere on the board
CTL_POWER: R33.1; also elsewhere on the board
CTL_RUN: Q2.3 (C), R31.2; also elsewhere on the board
FROM_CONVERTER: J5.2, R40.2, R41.2
GND: C13.2, C14.2, C15.1, C16.1, C17.1, C18.2, C19.1, C22.2, C23.2, C24.2, C25.2, J4.1, J5.1, J6.1, Q2.2 (E), R32.2, R35.1, TH1.2, TP4.1, U4.1 (GND), U5.2 (GND), U6.3 (GND), U6.7 (A0), U6.8 (A1), U7.3 (GND), U7.8 (A1); also elsewhere on the board
I2C_SCL: U6.5 (SCL), U7.5 (SCL); also elsewhere on the board
I2C_SDA: U6.6 (SDA), U7.6 (SDA); also elsewhere on the board
unnamed: D4.1 (K), R36.2
unnamed: Q1.2 (D), Q3.2 (D)
unnamed: C12.2, Q1.1 (G), Q3.1 (G), R30.2, R31.1
unnamed: Q2.1 (B), R32.1, R33.2
unnamed: R34.1, R35.2, U4.4 (PR1)
unnamed: R36.1, U4.8 (ST)
unnamed: C20.1, R37.2, U6.1 (IN+)
unnamed: C20.2, R39.1, U6.2 (IN-)
unnamed: C21.1, R40.1, U7.1 (IN+)
unnamed: C21.2, R42.1, U7.2 (IN-)
TO_CONVERTER: J4.2, R38.1, R39.2
USB_VBUS: C14.1, U4.6 (VIN2); also elsewhere on the board
VIN_5V: C13.1, C17.2, C19.2, D3.2 (A), R34.2, U4.3 (VIN1), U4.5 (MODE), U5.3 (OUT)
VREF_THERMISTOR: R29.1, TH1.1; also elsewhere on the board

Notes on the sheet:
ノイズなど，必要に応じて実装
MULTIPLEXER
THERMAL MONITOR
DC/DC CONVERTER 5V
CURRENT MONITOR
CONVERTER
LOAD SWITCH
POWER INPUT DC JACK 15-24V

Parts:
J7: CONN_STATUS_PANEL; DF51A-14DP-2DS; Mouser_PN 798-DF51A14DP2DS50
J8: CONN_BOARD_3; DF51A-6DP-2DSA; Mouser_PN 798-DF51A-6DP-2DSA
J9: CONN_PANEL_BOARD_1; DF51A-18DP-2DS; Digikey_PN 26-DF51A-18DP-2DS(20)-ND
J10: CONN_PANEL_BOARD_2; DF51A-22DP-2DS; Digikey_PN 26-DF51A-22DP-2DS(20)-ND

Connections:
7SEG_CLK: J7.5; also elsewhere on the board
7SEG_DIO: J7.6; also elsewhere on the board
CONN_LED_5V: J7.10, J7.14, J8.6, J9.18, J10.22; also elsewhere on the board
CONN_LED_12V: J7.11; also elsewhere on the board
CONN_LED_CLOSE: J10.16; also elsewhere on the board
CONN_LED_COM: J7.9; also elsewhere on the board
CONN_LED_DUMP: J10.15; also elsewhere on the board
CONN_LED_EMERGENCY: J10.21; also elsewhere on the board
CONN_LED_ERROR: J7.3; also elsewhere on the board
CONN_LED_FILL: J10.13; also elsewhere on the board
CONN_LED_IGNITOR: J10.12; also elsewhere on the board
CONN_LED_INPUT: J7.12; also elsewhere on the board
CONN_LED_LOW_VOLTAGE: J7.2; also elsewhere on the board
CONN_LED_O2: J10.17; also elsewhere on the board
CONN_LED_OPEN: J10.14; also elsewhere on the board
CONN_LED_PURGE: J10.18; also elsewhere on the board
CONN_LED_RS485_ACCESS: J7.4; also elsewhere on the board
CONN_LED_SAFTEY: J10.20; also elsewhere on the board
CONN_LED_SEQUENCE: J10.19; also elsewhere on the board
CONN_LED_SHIFT: J10.11; also elsewhere on the board
CONN_LED_TASK: J7.8; also elsewhere on the board
CONN_LED_USB_ACCESS: J7.7; also elsewhere on the board
CTL_CLOSE: J9.11; also elsewhere on the board
CTL_CONFIRM_1: J8.2; also elsewhere on the board
CTL_CONFIRM_2: J8.3; also elsewhere on the board
CTL_CONFIRM_3: J8.4; also elsewhere on the board
CTL_DUMP: J9.13; also elsewhere on the board
CTL_EMERGENCY_STOP: J9.3; also elsewhere on the board
CTL_FILL: J9.9; also elsewhere on the board
CTL_IGNITOR: J9.5; also elsewhere on the board
CTL_KILL: J9.8; also elsewhere on the board
CTL_O2: J9.17; also elsewhere on the board
CTL_OPEN: J9.7; also elsewhere on the board
CTL_PURGE: J9.15; also elsewhere on the board
CTL_RESET: J7.13; also elsewhere on the board
CTL_RUN: J9.10; also elsewhere on the board
CTL_SAFETY: J9.2; also elsewhere on the board
CTL_SEQUENCE_START: J9.4; also elsewhere on the board
CTL_SHIFT: J9.6; also elsewhere on the board
GND: J7.1, J9.1, J10.1; also elsewhere on the board

Parts:
D6, D13, D15: LED_G; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; Digikey_PN SML-D12P8WT86CCT-ND
D7, D8, D9, D11, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26: LED_O; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; Digikey_PN SML-D15DWT86CCT-ND
D10: LED_B; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; Digikey_PN SMLD12BN1WT86CT-ND
D12, D14: LED_R; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; Digikey_PN SML-D12U8WT86CCT-ND
R46, R48, R50, R51, R52, R53, R54, R55, R56, R57, R58, R59, R60, R61, R62, R63, R64, R65, R66: 1kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Digikey_PN 2019-RK73H1JTTD1001FCT-ND
R47, R49: 5.1kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Digikey_PN 2019-RK73H1JTTD5101FCT-ND

Connections:
CONN_LED_5V: D6.2 (A), D8.2 (A), R51.1; also elsewhere on the board
CONN_LED_12V: R49.1; also elsewhere on the board
CONN_LED_CLOSE: R64.1; also elsewhere on the board
CONN_LED_COM: R53.1; also elsewhere on the board
CONN_LED_DUMP: R63.1; also elsewhere on the board
CONN_LED_EMERGENCY: R58.1; also elsewhere on the board
CONN_LED_ERROR: R52.1; also elsewhere on the board
CONN_LED_FILL: R61.1; also elsewhere on the board
CONN_LED_IGNITOR: R60.1; also elsewhere on the board
CONN_LED_INPUT: R47.1; also elsewhere on the board
CONN_LED_LOW_VOLTAGE: R54.1; also elsewhere on the board
CONN_LED_O2: R65.1; also elsewhere on the board
CONN_LED_OPEN: R62.1; also elsewhere on the board
CONN_LED_PURGE: R66.1; also elsewhere on the board
CONN_LED_RS485_ACCESS: R50.1; also elsewhere on the board
CONN_LED_SAFTEY: R57.1; also elsewhere on the board
CONN_LED_SEQUENCE: R56.1; also elsewhere on the board
CONN_LED_SHIFT: R59.1; also elsewhere on the board
CONN_LED_TASK: R55.1; also elsewhere on the board
CONN_LED_USB_ACCESS: R46.2; also elsewhere on the board
GND: D7.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), D25.1 (K), D26.1 (K); also elsewhere on the board
LED_USB_TXLED: R48.2; also elsewhere on the board
unnamed: D6.1 (K), R46.1
unnamed: D7.2 (A), R47.2
unnamed: D8.1 (K), R48.1
unnamed: D9.2 (A), R49.2
unnamed: D10.2 (A), R50.2
unnamed: D11.2 (A), R51.2
unnamed: D12.2 (A), R52.2
unnamed: D13.2 (A), R53.2
unnamed: D14.2 (A), R54.2
unnamed: D15.2 (A), R55.2
unnamed: D16.2 (A), R56.2
unnamed: D17.2 (A), R57.2
unnamed: D18.2 (A), R58.2
unnamed: D19.2 (A), R59.2
unnamed: D20.2 (A), R60.2
unnamed: D21.2 (A), R61.2
unnamed: D22.2 (A), R62.2
unnamed: D23.2 (A), R63.2
unnamed: D24.2 (A), R64.2
unnamed: D25.2 (A), R65.2
unnamed: D26.2 (A), R66.2

Notes on the sheet:
LED_PURGE
LED_O2
LED_SHIFT
LED_DUMP
LED_RS485_ACCESS
LED_EMERGENCY
LED_IGNITOR
LED_ERROR
LED_LOW_VOLTAGE
LED_CLOSE
LED_INPUT
LED_5V
LED_12V
LED_SEQUENCE
LED_TASK
LED_COM
LED_FILL
LED_OPEN
LED_SAFETY
LED_USB_ACCESS

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
Board: 2 copper layers, 150.0 x 100.0 mm, 184 parts (0 on the bottom side), 132 nets.

## KiCad design KiCad/StatusPanel/StatusPanel.kicad_pcb

Parts:
C1, C2, C3: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C4: 100uF; C_Elec_6.3x7.7
J1: CONN; DF11CZ-16DP-2V
J2: CONN_RESET_CTL; 1p
J3: CONN_RESET_GND; 1p
J4: CONN_USB_5V; 1p
J5: CONN_USB_CTL; 1p
J6: CONN_INPUT_CTL; 1p
J7: CONN_INPUT_GND; 1p
J8: CONN_RS485_CTL; 1p
J9: CONN_RS485_GND; 1p
J10: CONN_12V_CTL; 1p
J11: CONN_12V_GND; 1p
J12: CONN_TASK_CTL; 1p
J13: CONN_TASK_GND; 1p
J14: CONN_5V_CTL; 1p
J15: CONN_5V_GND; 1p
J16: CONN_COM_CTL; 1p
J17: CONN_COM_GND; 1p
J18: CONN_LOW_CTL; 1p
J19: CONN_LOW_GND; 1p
J20: CONN_ERROR_CTL; 1p
J21: CONN_ERROR_GND; 1p
R1, R2, R3, R4, R5, R6, R7, R8, R9: 270R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1: 2281SB; Sx39-1xxxxx
U2: TM1637; SOP-20_7.5x12.8mm_P1.27mm

Connections:
5V: J1.11, R6.1
12V: J1.5, R4.1
+5V: C1.2, C4.1, J1.6, J4.1, U2.16 (VDD)
CLK: C2.2, J1.10, U2.18 (CLK)
COM: J1.13, R7.1
DIO: C3.2, J1.12, U2.17 (DIO)
ERROR: J1.16, R9.1
GND: C1.1, C2.1, C3.1, C4.2, J1.8, J1.9, J1.14, J3.1, J7.1, J9.1, J11.1, J13.1, J15.1, J17.1, J19.1, J21.1, U2.1 (GND)
INPUT: J1.1, R2.1
LOW: J1.15, R8.1
unnamed: J5.1, R1.1
unnamed: J6.1, R2.2
unnamed: J8.1, R3.2
unnamed: J10.1, R4.2
unnamed: J12.1, R5.2
unnamed: J14.1, R6.2
unnamed: J16.1, R7.2
unnamed: J18.1, R8.2
unnamed: J20.1, R9.2
unnamed: U1.7 (A), U2.2 (SEG1/KS1)
unnamed: U1.8 (B), U2.3 (SEG2/KS2)
unnamed: U1.3 (C), U2.4 (SEG3/KS3)
unnamed: U1.2 (D), U2.5 (SEG4/KS4)
unnamed: U1.9 (DEG1), U2.14 (GRID2)
unnamed: U1.6 (DEG2), U2.15 (GRID1)
unnamed: U1.5 (DP), U2.9 (SEG8/KS8)
unnamed: U1.1 (E), U2.6 (SEG5/KS5)
unnamed: U1.10 (F), U2.7 (SEG6/KS6)
unnamed: U1.4 (G), U2.8 (SEG7/KS7)
RESET: J1.4, J2.1
RS485: J1.3, R3.1
TASK: J1.7, R5.1
USB: J1.2, R1.2

Board: 2 copper layers, 121.0 x 92.0 mm, 36 parts (35 on the bottom side), 33 nets.

## KiCad design KiCad/SatelliteNode/SatelliteNode.kicad_pcb

Parts:
C1, C3, C4: 0.1uF; C_0603_1608Metric
D1: BZX55C3V3; D_DO-35_SOD27_P7.62mm_Horizontal
D2: RB160M-30TR; SOD-123FL_Handsolder
F1: MF-R050; Fuse_Bourns_MF-RG300
H1, H2, H3: MountingHole; MountingHole_3.2mm_M3
J1: 12V_Connector; DF51A-2P-2DSA
J2: Isolated_RS485; StrawberryLinux_ADM2582
J3, J4, J5, J6, J7, J8: Conn_01x04; DF51A-4P-2DSA
R1, R2: 4.7kR; R_0603_1608Metric
R3, R5: 10kR 1%; R_0603_1608Metric
R4, R6, R7, R8, R9, R10: 10kR; R_0603_1608Metric
U2: SSD1306
U3: XIAO-ESP32-C6; XIAO-ESP32-C6-DIP
U4: MCP23017_SP; DIP-28_W7.62mm
U5: 74HC14; DIP-14_W7.62mm_LongPads
U6: BP5293-50; TO-220F-3_Vertical

Connections:
5V_ADC: C1.2, D1.1 (K), R3.2, R5.2, U3.2 (GPIO1/A1/D1)
+3.3V: C3.1, C4.1, J2.10, J3.2, J4.2, J5.2, J6.2, J7.2, J8.2, R1.1, R2.1, R4.1, R6.1, R7.1, R8.1, R9.1, R10.1, U2.2 (VCC), U3.12 (3V3), U4.9 (VDD), U4.18 (~RESET), U5.14 (VCC)
+5V: D2.2 (A), R3.1, U6.3 (VOUT)
+12V: F1.1, J1.2
GND: C1.1, C3.2, C4.2, D1.2 (A), J1.1, J2.9, J3.1, J4.1, J5.1, J6.1, J7.1, J8.1, R5.1, U2.1 (GND), U3.13 (GND), U4.10 (VSS), U4.15 (A0), U4.16 (A1), U4.17 (A2), U5.7 (GND), U6.2 (GND)
I2C_SCL: R2.2, U2.3 (SCL), U3.6 (GPIO23/D5/SCL), U4.12 (SCK)
I2C_SDA: R1.2, U2.4 (SDA), U3.5 (GPIO22/D4/SDA), U4.13 (SDA)
LED_CTL_0: J3.4, U4.1 (GPB0)
LED_CTL_1: J4.4, U4.2 (GPB1)
LED_CTL_2: J5.4, U4.3 (GPB2)
LED_CTL_3: J6.4, U4.4 (GPB3)
LED_CTL_4: J7.4, U4.5 (GPB4)
LED_CTL_5: J8.4, U4.6 (GPB5)
unnamed: D2.1 (K), U3.14 (VBUS)
unnamed: J3.3, R4.2, U5.1
unnamed: J4.3, R6.2, U5.3
unnamed: J5.3, R7.2, U5.5
unnamed: J6.3, R8.2, U5.9
unnamed: J7.3, R9.2, U5.11
unnamed: J8.3, R10.2, U5.13
unnamed: F1.2, U6.1 (VIN)
RS485_DI: J2.5, U3.7 (GPIO16/D6/TX)
RS485_RO: J2.3, U3.8 (GPIO17/D7/RX)
RS485_~RE_DE: J2.15, J2.17, U3.1 (GPIO0/A0/D0)
SPI_MISO: U3.10 (GPIO20/D9/MISO)
SPI_MOSI: U3.11 (GPIO18/D10/MOSI)
SPI_SCK: U3.9 (GPIO19/D8/SCK)
Switch_Out_0: U4.23 (GPA2), U5.2
Switch_Out_1: U4.22 (GPA1), U5.4
Switch_Out_2: U4.21 (GPA0), U5.6
Switch_Out_3: U4.26 (GPA5), U5.8
Switch_Out_4: U4.25 (GPA4), U5.10
Switch_Out_5: U4.24 (GPA3), U5.12
